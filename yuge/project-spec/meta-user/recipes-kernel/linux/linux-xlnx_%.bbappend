SRC_URI += "file://user_2017-11-13-11-01-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

