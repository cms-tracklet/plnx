IMAGE_INSTALL_append = " xvcServer-init"
